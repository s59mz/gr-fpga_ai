options:
  parameters:
    generate_options: qt_gui
    id: rf_class
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/root/app/brisi.bin
    type: short
  states: {state: disabled}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
    vlen: '1024'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: fpga_ai_rf_classf_0
  id: fpga_ai_rf_classf
  parameters:
    model_filename: /home/root/gr-fpga_ai/examples/rfClassification.xmodel
  states: {}
- name: fpga_ai_sample_mod_src_0
  id: fpga_ai_sample_mod_src
  parameters:
    classes_file: /home/root/gr-fpga_ai/examples/rf_classes.npy
    index: '100'
    samples_file: /home/root/gr-fpga_ai/examples/rf_input.npy
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '26'
    grid: 'True'
    marker1: '0'
    size: '32'
    style1: '3'
    type: float
    xmax: '23'
    xmin: '-1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_short_to_float_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_throttle_0, '0', fpga_ai_rf_classf_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [fpga_ai_rf_classf_0, '0', blocks_file_sink_0, '0']
- [fpga_ai_rf_classf_0, '0', blocks_short_to_float_0, '0']
- [fpga_ai_sample_mod_src_0, '0', blocks_throttle_0, '0']
- [fpga_ai_sample_mod_src_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
